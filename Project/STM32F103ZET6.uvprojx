# Keil uVision project STM32F103ZET6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\User\HARDWARE\inc;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\FFT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HARDWARE
    ../User/HARDWARE/src/: MAX7219.c delay.c adc.c time.c dma.c
  group FFT
    ../FFT/: cr4_fft_256_stm32.s FFT.c
  group DOC
    ../Doc/: readme.txt
